# Keil uVision project Project.uvproj, settings and files
target bootloader (ARM-ADS)
  device: GD32F450VI GigaDevice
  cpu: IRAM(0x20000000-0x2006FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x081FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Utilities;..\Firmware\CMSIS;..\;..\Firmware\CMSIS\GD\GD32F4xx\Source\ARM;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Drivers;..\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: gd32f4xx_it.c main.c systick.c update_my_self.c
  group Drivers
    ../Drivers/: led.c com.c delay.c fmc_operation.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Peripherals
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rtc.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_gpio.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_rcu.c gd32f4xx_trng.c gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Utilities
    ../Utilities/: gd32f450i_eval.c
  group Doc
    ../: readme.txt
  group Common
    ../common/: fifo.c crc16.c
